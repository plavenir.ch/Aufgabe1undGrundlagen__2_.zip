Properties of the parts of a building model (IFC4)

# File
Description: no view
File name: 3D Modell.ifc
Time: 2026-03-28T10:35:55
Author: Corina Rusch
Organization: RKL AG Ingenieure & Planer, Breitfeldstrasse 10, 9015 St. Gallen
Written by: ODA SDAI 25.4
Authorization: corin

# IfcProject, Privat Corina Rusch
AllplanAttributes - Bauvorhaben: Ersetzen

# IfcBuildingStorey, Geometer
In: Grundlagen
Elevation: 0 m
